Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-09T14:44:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 09 14:44:52 2021 * Host: DESKTOP-JA1LLOH * Database: C:\Users\Vlad\AppData\Local\Temp\{1E0612AB-C8B6-472F-9DE5-A763A53015CA}\ifc * Database version: 5507 * Database creation date: Mon Aug 09 14:44:52 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 09 14:44:52 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 09 14:44:52 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth, 6614CZ(2021):6614CZ Cover part for washbasin faucet, 3 V, Bluetooth:367836
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions - NominalDepth: 260 mm; NominalHeight: 170 mm; NominalWidth: 170 mm; Projection: 245 mm
Type - Electrical Engineering - Battery: AA 1.5 V Lithium x 2; Bluetooth: 5.x; Electrical Connection: 12 V; Electronic Parts: Autofocus sensor;Solenoid valve;Control unit;Signal lights;Low battery indication; Operating Voltage: 312 V
Type - General - Author: BIMstone; BIMObjectName: 6614CZ(2021); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/07/2021
Type - Green Building Properties - Backflow Prevention EN1717: AA; Customs Code: 84819000; EAN Number: 6414150098994; EMC Directive: 2014/53/EU; EN Standard: EN 15091; Noise Class: I (ISO 3822)
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/6614CZ; Catalog Drawing URL: http://static.oras.com/catdrw/6614CZ; Class: Trim Kit;Touchless;Battery-operated;Separate transformer; Dimension Drawing URL: http://static.oras.com/dimdrw/6614CZ; FDV Document URL: http://www.oras.com/datasheet/6614CZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/6614CZ; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;POL;RUS;EST;LTU;LVA;UKR; Model: 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth; Name_en: 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6614CZ; Product Datasheet: http://www.oras.com/datasheet/6614CZ/en; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/6614CZ; Product URL: http://static.oras.com/6614CZ; Technical DataSheet URL: http://www.oras.com/datasheet/6614CZ/en; Type Name: 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Adjustable settings (via bluetooth); Aerator: CASCADE®;Pressure controlled aerator; Afterflow Period: 3120; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); CWFU: 0; Flow Rate At 300kPa With Flow Controller: 0.00282517 m3/s; Included: Round rosette; Installation and Maintenance: http://static.oras.com/manual/6614CZ; Installation Type: Wall mounted for concealed unit; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 211800; Mechanical Parts: Mixing valve;Non-return valve(s);Litter filter(s); Not Included: WithoutTransformer; Protection Class: IP 55; Temperature: Temperature regulator
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6614CZ(2021); Features: Trim Kit;Touchless;Battery-operated;Separate transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6614CZ; Name: 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: 170x170x260 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.1173 m2; Volume: 0.007514 m3
Identity Data - Mark: 12
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 6614CZ(2021): 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth; Family and Type: 6614CZ(2021): 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6614CZ(2021): 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth; Type Id: 6614CZ(2021): 6614CZ Cover part for washbasin faucet, 3 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
